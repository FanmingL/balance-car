# Keil uVision project BalanceCar.uvprojx, settings and files
target BalanceCar (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BalanceCar +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: .\drivers;.\libraries\STLibraries;.\users;.\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group drivers
    ./drivers/: led.c timer.c usart.c bsp.c i2c_soft.c encoder.c pwm.c gpio.c bsp_flash.c
  group libraries
    ./users/: stm32f4xx_conf.h startup_stm32f40xx.s
    ./libraries/STLibraries/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c system_stm32f4xx.c
  group users
    ./users/: main.c
  group mpu6050
    ./drivers/: mpu6050.c ak8975.c
    ./app/: imu.c
  group app
    ./app/: DataTransfer.c ControlTask.c pid.c mymath.c filter.c parameter.c
